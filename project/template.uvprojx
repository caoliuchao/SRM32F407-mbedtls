# Keil uVision project template.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED=1
  c include: ..\CMSIS\Inc;..\FWLIB\Inc;..\FWLIB\StartUp;..\FWLIB\SystemInc;..\Interrupt\Inc;..\Drives\Inc;..\BSP\Inc;..\task\Inc;..\UCOSIII\uc-BSP\Inc;..\UCOSIII\uC-CONFIG\Inc;..\UCOSIII\uC-CPU\Inc;..\UCOSIII\uC-LIB\Inc;..\UCOSIII\uCOS-III\Inc;..\UCOSIII\uCOS-III\User;..\mbedtls\include;..\mbedtls\configs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group project
    ./: main.c
  group BSP
    ../BSP/Src/: Sysbsp.c
  group task
    ../task/Src/: task.c
  group System
    ../Drives/Src/: delay.c led.c sys.c usart.c key.c
  group StartUp
    ../FWLIB/StartUp/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/Src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fsmc.c
  group CMSIS
    ../FWLIB/SystemSrc/: system_stm32f4xx.c
  group Interrupt
    ../Interrupt/Src/: stm32f4xx_it.c
  group uC-LIB
    ../UCOSIII/uC-LIB/Src/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uC-BSP
    ../UCOSIII/uc-BSP/Src/: bsp.c
  group uC-CPU
    ../UCOSIII/uC-CPU/Src/: cpu_c.c cpu_core.c cpu_a.asm
  group uC-USER
    ../UCOSIII/uCOS-III/User/: os_cpu_a.asm os_cpu_c.c
  group uC-CONFIG
    ../UCOSIII/uC-CONFIG/Inc/: os_cfg.h includes.h os_cfg_app.h
    ../UCOSIII/uC-CONFIG/Src/: os_app_hooks.c
  group uC-UCOSIII
    ../UCOSIII/uCOS-III/Src/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group security
    ../mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../mbedtls/configs/: mbedTLS_config.h
